## config/boards/shields/Macro3x3/Kconfig.defconfig
```kconfig
if SHIELD_Macro3X3

    config ZMK_KEYBOARD_NAME
        default "Macro3x3"

endif
```
